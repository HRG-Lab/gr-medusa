options:
  parameters:
    author: gaylybailey
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: medusa_opencv_aruco_calc_steering_vecs_0
  id: medusa_opencv_aruco_calc_steering_vecs
  parameters:
    calibration_file: /home/gaylybailey/Documents/Programming/OpenCVSandbox/logitech_brio.yaml
    dictionary: '0'
    draw_markers: 'True'
    draw_poses: 'True'
    element_ids: '[1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32]'
    marker_side_length: '0.05'
    origin_id: '36'
    resolution: 1920x1080
    video_source: '2'
  states: {}

connections:
- [medusa_opencv_aruco_calc_steering_vecs_0, frame, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
