options:
  parameters:
    author: gaylybailey
    generate_options: qt_gui
    id: mmse
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: intf_amplitude
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: intf_angle
  id: variable
  parameters:
    value: (-40, 0)
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: phis
  id: variable
  parameters:
    value: np.linspace(0, np.pi, 181)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sig_amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: soi_angle
  id: variable
  parameters:
    value: (40, 0)
  states: {}
- name: thetas
  id: variable
  parameters:
    value: np.linspace(-np.pi, np.pi, 361)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: sig_amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: intf_amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: N
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt("")
    period: '1000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '6'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: N
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from scipy.constants import speed_of_light
      from gnuradio import gr
      from gnuradio.gr import pmt


      def sample_spherical(npoints, ndim=3):
          vec = np.random.randn(ndim, npoints)
          vec /= np.linalg.norm(vec, axis=0)
          return vec


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_elems=8, freq=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Random Positions',
                  in_sig=None,
                  out_sig=None
              )
              self.n_elems = n_elems
              self.freq = freq
              self.wavelen = speed_of_light / self.freq
              self.elems = self.wavelen * sample_spherical(self.n_elems).T
              self.rng = np.random.default_rng()
              
              self.message_port_register_in(pmt.intern("trigger"))
              self.set_msg_handler(pmt.intern("trigger"), self.handler)
              
              self.message_port_register_out(pmt.intern("positions"))


          def handler(self, msg):
              perturbations = self.rng.standard_normal(size=self.elems.shape)
              self.elems += perturbations
              
              self.message_port_pub(
                  pmt.intern("positions"), 
                  pmt.to_pmt(self.elems)
              )
    freq: freq
    n_elems: N
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: medusa_array_plot_3d_0
  id: medusa_array_plot_3d
  parameters:
    gui_hint: 0,0,1,1
  states: {}
- name: medusa_calc_steering_vec_0
  id: medusa_calc_steering_vec
  parameters:
    frequency: freq
    phis: phis
    thetas: thetas
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sig_0
  id: sig
  parameters:
    freq: freq
    n_elems: N
    noise_power: noise_power
    samp_rate: samp_rate
    soi_angle: intf_angle
  states: {}
- name: sig_0_0
  id: sig
  parameters:
    freq: freq
    n_elems: N
    noise_power: noise_power
    samp_rate: samp_rate
    soi_angle: soi_angle
  states: {}

connections:
- [analog_sig_source_x_0, '0', sig_0_0, '0']
- [analog_sig_source_x_0_0, '0', sig_0, '0']
- [blocks_add_xx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_null_sink_0, '1']
- [blocks_vector_to_streams_0, '4', blocks_null_sink_0, '2']
- [blocks_vector_to_streams_0, '5', blocks_null_sink_0, '3']
- [blocks_vector_to_streams_0, '6', blocks_null_sink_0, '4']
- [blocks_vector_to_streams_0, '7', blocks_null_sink_0, '5']
- [epy_block_0, positions, medusa_array_plot_3d_0, positions]
- [epy_block_0, positions, medusa_calc_steering_vec_0, positions]
- [medusa_calc_steering_vec_0, vecs, sig_0, steering_vectors]
- [medusa_calc_steering_vec_0, vecs, sig_0_0, steering_vectors]
- [sig_0, '0', blocks_add_xx_0, '1']
- [sig_0_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
