options:
  parameters:
    author: gaylybailey
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: intf_phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 'main_tab@1: 1, 1, 1, 1'
    label: Interferer Angle [phi]
    rangeType: int
    start: '0'
    step: '1'
    stop: '180'
    value: '10'
  states: {state: disabled}
- name: intf_theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 'main_tab@1: 1, 0, 1, 1'
    label: Interferer Angle [theta]
    rangeType: int
    start: '-180'
    step: '1'
    stop: '180'
    value: '80'
  states: {state: disabled}
- name: num_elems
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: sig_phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 'main_tab@1: 0, 1, 1, 1'
    label: Signal Angle [phi]
    rangeType: int
    start: '0'
    step: '1'
    stop: '180'
    value: '80'
  states: {state: disabled}
- name: sig_theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 'main_tab@1: 0, 0, 1, 1'
    label: Signal Angle [theta]
    rangeType: int
    start: '-180'
    step: '1'
    stop: '180'
    value: '20'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbols_per_byte
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: 3 * 1920 * 1080
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
    vlen: num_elems
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import pmt


      class msg_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Debug',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("msg"))
              self.set_msg_handler(pmt.intern("msg"), self.handle_msg)

          def handle_msg(self, msg):
              pass
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 2, 2
    label0: Markers
    label1: TX/RX
    num_tabs: '2'
  states: {state: disabled}
- name: medusa_array_sim_0
  id: medusa_array_sim
  parameters:
    num_elems: num_elems
    signal_angle_phi: sig_phi
    signal_angle_theta: sig_theta
    wavelen: '0.25'
  states: {state: disabled}
- name: medusa_beamformer_0
  id: medusa_beamformer
  parameters:
    algorithm: medusa.MMSE
    intf_phi: '0'
    intf_theta: '0'
    noise_power: '0.001'
    nstreams: num_elems
    signal_phi: sig_phi
    signal_power: '1'
    signal_theta: sig_theta
  states: {state: disabled}
- name: medusa_estimate_poses_0
  id: medusa_estimate_poses
  parameters:
    calibration_file: /home/gaylybailey/Documents/Programming/OpenCVSandbox/logitech_brio.yaml
    marker_side_length: '0.05'
    resolution: 1920x1080
  states: {state: disabled}
- name: medusa_opencv_aruco_corner_source_0
  id: medusa_opencv_aruco_corner_source
  parameters:
    adaptiveThreshConstant: '7.0'
    adaptiveThreshWinSizeMax: '23'
    adaptiveThreshWinSizeMin: '3'
    adaptiveThreshWinSizeStep: '10'
    calibration_file: /home/gaylybailey/Documents/Programming/OpenCVSandbox/logitech_brio.yaml
    cornerRefinementMaxIterations: '30'
    cornerRefinementMethod: '0'
    cornerRefinementMinAccuracy: '0.1'
    cornerRefinementWinSize: '5'
    detectInvertedMarker: 'False'
    dictionary: '0'
    draw_markers: 'True'
    draw_poses: 'True'
    errorCorrectionRate: '0.6'
    markerBorderBits: '1'
    marker_side_length: '0.10'
    maxErroneousBitsInBorderRate: '0.35'
    maxMarkerPerimeterRate: '4.0'
    minCornerDistanceRate: '0.05'
    minDistanceToBorder: '3'
    minMarkerDistanceRate: '0.05'
    minMarkerLengthRatioOriginalImg: '0.0'
    minMarkerPerimeterRate: '0.03'
    minOtsuStdDev: '5.0'
    minSideLengthCanonicalImg: '32'
    perspectiveRemoveIgnoredMarginPerCell: '0.13'
    perspectiveRemovePixelPerCell: '4'
    polygonalApproxAccuracyRate: '0.03'
    resolution: 1280x720
    useAruco3Detection: 'True'
    video_source: '0'
  states: {}
- name: medusa_plot_3d_positions_0
  id: medusa_plot_3d_positions
  parameters:
    gui_hint: 'main_tab@0: 1, 0, 1, 1'
  states: {state: disabled}
- name: medusa_plot_3d_positions_0_0
  id: medusa_plot_3d_positions
  parameters:
    gui_hint: 0, 1, 1, 1
  states: {}
- name: medusa_plot_array_factor_contour_0
  id: medusa_plot_array_factor_contour
  parameters:
    auto_scale: 'False'
    background: default
    cmap: viridis
    draw_isos: 'False'
    gui_hint: 0, 2, 2, 2
    num_levels: '10'
    signal_angle_phi: sig_phi
    signal_angle_theta: sig_theta
    title: Array Factor
    x_tick_spacing: '15'
    y_tick_spacing: '30'
  states: {state: disabled}
- name: medusa_positions_to_steering_vecs_0
  id: medusa_positions_to_steering_vecs
  parameters:
    element_ids: '[1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32]'
    marker_length: '0.05'
    origin_id: '36'
    update_rate: '0.5'
  states: {state: disabled}
- name: medusa_positions_to_steering_vecs_0_0
  id: medusa_positions_to_steering_vecs
  parameters:
    element_ids: '[1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32]'
    marker_length: '0.05'
    origin_id: '0'
    update_rate: '1'
  states: {}
- name: medusa_qlabel_video_sink_0_0
  id: medusa_qlabel_video_sink
  parameters:
    gui_hint: 0, 0, 1, 1
    resolution: 1280x720
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'main_tab@1: 4, 0, 2, 2'
    name: '"RX"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'main_tab@1: 2, 0, 2, 2'
    name: '"TX"'
    size: '1024'
    type: complex
  states: {state: disabled}

connections:
- [analog_random_source_x_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0_0, '0', medusa_array_sim_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_vector_source_x_0, '0', medusa_beamformer_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [medusa_array_sim_0, '0', qtgui_const_sink_x_0, '0']
- [medusa_array_sim_0, plot, medusa_plot_array_factor_contour_0, plot]
- [medusa_beamformer_0, weights, medusa_array_sim_0, weights]
- [medusa_estimate_poses_0, '0', blocks_null_sink_0, '0']
- [medusa_opencv_aruco_corner_source_0, '0', medusa_qlabel_video_sink_0_0, '0']
- [medusa_opencv_aruco_corner_source_0, frame_info, medusa_positions_to_steering_vecs_0_0, frame_info]
- [medusa_positions_to_steering_vecs_0, positions, medusa_plot_3d_positions_0, positions]
- [medusa_positions_to_steering_vecs_0, steering vecs, medusa_array_sim_0, steering vecs]
- [medusa_positions_to_steering_vecs_0, steering vecs, medusa_beamformer_0, steering vecs]
- [medusa_positions_to_steering_vecs_0_0, positions, medusa_plot_3d_positions_0_0, positions]
- [medusa_positions_to_steering_vecs_0_0, steering vecs, epy_block_0, msg]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
