options:
  parameters:
    author: gaylybailey
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '245760000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: medusa_aruco_detector_0
  id: medusa_aruco_detector
  parameters:
    dictionary: '0'
    resolution: 640x480
  states: {}
- name: medusa_estimate_poses_0
  id: medusa_estimate_poses
  parameters:
    calibration_file: /home/gaylybailey/Documents/Programming/OpenCVSandbox/logitech_brio.yaml
    marker_side_length: '0.1'
    resolution: 640x480
  states: {}
- name: medusa_opencv_source_0
  id: medusa_opencv_source
  parameters:
    resolution: 640x480
    video_source: '0'
  states: {}
- name: medusa_qlabel_video_sink_0
  id: medusa_qlabel_video_sink
  parameters:
    gui_hint: 0, 1, 1, 1
    resolution: 640x480
  states: {}
- name: medusa_qlabel_video_sink_0_0
  id: medusa_qlabel_video_sink
  parameters:
    gui_hint: 0, 0, 1, 1
    resolution: 640x480
  states: {}

connections:
- [medusa_aruco_detector_0, '0', medusa_estimate_poses_0, '0']
- [medusa_aruco_detector_0, '0', medusa_qlabel_video_sink_0_0, '0']
- [medusa_estimate_poses_0, '0', medusa_qlabel_video_sink_0, '0']
- [medusa_opencv_source_0, '0', medusa_aruco_detector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
